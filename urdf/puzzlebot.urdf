Commit message: Code to implement Kalman Location with ArUcos in Puzzlebot

File: urdf/puzzlebot.urdf (robot description, URDF)
Before this commit: robot puzzlebot, 7 links, 6 joints
Joints:
- joint laser_joint: origin xyz=0.0 0.0 0.1 rpy=0 0 0 -> xyz=0.0 0.0 0.1 rpy=0 0 1.57
